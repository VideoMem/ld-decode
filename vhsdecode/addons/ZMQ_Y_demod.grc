options:
  parameters:
    generate_options: qt_gui
    id: zmq_sink
    output_language: python
    title: External luminance demod
  states: {}

blocks:
- name: Fc
  id: variable
  parameters:
    comment: 40 * Fh (NTSC)
    value: 40 * Fh
  states: {}
- name: Fh
  id: variable
  parameters:
    comment: |-
      15.625e3 (PAL)
      15.734e3 (NTSC)
    value: Fv*lines_per_frame/2
  states: {}
- name: Fs
  id: variable
  parameters:
    comment: |-
      Fh * (284-1/4) + Fh/625 (pal)
      455 * Fh / 2 (NTSC)
    value: 455 * Fh / 2
  states: {}
- name: Fv
  id: variable
  parameters:
    comment: |-
      50 (PAL)
      60 (NTSC)
    value: '60'
  states: {}
- name: disp_columns
  id: variable
  parameters:
    value: '910'
  states: {}
- name: disp_lines
  id: variable
  parameters:
    value: '263'
  states: {}
- name: dots
  id: variable
  parameters:
    value: disp_lines * disp_columns
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    comment: |-
      625 (PAL)
      526 (NTSC)
      624 (PAL 624)
    value: '526'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: sdl_rate
  id: variable
  parameters:
    value: dots*Fv
  states: {}
- name: vco_deviation
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: ynr_fineadj
  id: variable_qtgui_range
  parameters:
    gui_hint: '[3, 0, 1, 1]'
    label: YNR delay fine adjust
    orient: Qt.Horizontal
    start: '50'
    step: '4'
    stop: '130'
    value: '113'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '3000'
    type: float
  states: {state: disabled}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    comment: |-
      1.25e-6 VHS
      600e-9 UMATIC
    samp_rate: samp_rate
    tau: '1.3e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*vco_deviation/8.0)
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '14'
    decim: '1'
    gain: '1'
    high_cutoff_freq: Fs + (310 * Fh /2)
    low_cutoff_freq: Fs - (310 * Fh /2)
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e6
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    beta: '14'
    decim: '1'
    gain: '1'
    high_cutoff_freq: Fs + (301 * Fh /2)
    low_cutoff_freq: Fs - (301 * Fh /2)
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e6
    win: firdes.WIN_KAISER
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '7.43'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(samp_rate/Fh) - ynr_fineadj
    type: float
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '0xFF'
  states: {state: disabled}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate*disp_lines/Fh)
    max_iter: '4000'
    scale: 1/int(samp_rate*disp_lines/Fh)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/2
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.001'
    type: float
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[1, 1]'
    type: short
    vlen: disp_columns
  states: {state: disabled}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    type: short
    vlen: dots
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: dots
    type: short
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: disp_lines
    type: short
    vlen: disp_columns
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: disp_lines
    type: short
    vlen: disp_columns
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: disp_columns
    type: short
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: Fs
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,3e6,1e6)
    type: ccf
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.1'
    grid: 'True'
    gui_hint: '[1,1,1,1]'
    legend: 'False'
    name: '"Input phase"'
    size: '1024'
    style1: '1'
    type: complex
    xmax: '3500'
    xmin: '-3500'
    ymax: '3500'
    ymin: '-3500'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: '[ 1 , 0 , 1, 1]'
    legend: 'False'
    name: '"Input spectra"'
    nconnections: '2'
    type: float
    wintype: firdes.WIN_KAISER
    ymax: '60'
    ymin: '-42'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: '[3,1,1,2]'
    max: '12'
    min: '7'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: '[0,0,1,1]'
    legend: 'False'
    name: '"Input waveform"'
    size: int(2*samp_rate/Fh)
    srate: samp_rate
    type: complex
    ymax: '3500'
    ymin: '-3500'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[0,1,1,2]'
    legend: 'False'
    name: '"Video Out"'
    nconnections: '2'
    size: int(2*samp_rate/Fh)
    srate: samp_rate
    tr_level: '0.4'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '9'
    ymin: '-0.7'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/3
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    gui_hint: '[1,2,1,1]'
    legend: 'False'
    name: '"Video Out Spectra"'
    type: float
    wintype: firdes.WIN_KAISER
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(sdl_rate/samp_rate).limit_denominator(1000).denominator
    interp: Fraction(sdl_rate/samp_rate).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {state: disabled}
- name: video_sdl_sink_0_1
  id: video_sdl_sink
  parameters:
    display_height: lines_per_frame
    display_width: disp_columns
    fps: '0'
    height: lines_per_frame
    type: short
    width: disp_columns
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: luma_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: luma_out
  states: {state: disabled}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:5566
    timeout: '100'
    type: float
  states: {state: disabled}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [analog_fm_deemph_0_0, '0', blocks_add_xx_0, '0']
- [analog_fm_deemph_0_0, '0', blocks_delay_0, '0']
- [analog_fm_deemph_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0_0, '0']
- [band_pass_filter_0, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_1, '0']
- [band_pass_filter_0_0, '0', blocks_rms_xx_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_magphase_to_complex_0, '1']
- [blocks_delay_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_short_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_complex_to_float_0, '0']
- [blocks_magphase_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_magphase_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_magphase_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', zeromq_rep_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_stream_mux_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_stream_to_streams_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_streams_0, '1', blocks_vector_to_stream_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_stream_to_streams_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_vector_to_stream_1, '0', video_sdl_sink_0_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', blocks_add_const_vxx_0_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_1, '0']
- [zeromq_req_source_0, '0', blocks_complex_to_float_0, '0']
- [zeromq_req_source_0, '0', blocks_complex_to_magphase_0, '0']
- [zeromq_req_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [zeromq_req_source_0, '0', qtgui_const_sink_x_0, '0']
- [zeromq_req_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
