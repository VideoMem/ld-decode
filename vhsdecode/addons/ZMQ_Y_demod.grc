options:
  parameters:
    generate_options: qt_gui
    id: zmq_sink
    output_language: python
    title: External luminance demod
  states: {}

blocks:
- name: Fc
  id: variable
  parameters:
    comment: 40 * Fh (NTSC)
    value: 40 * Fh
  states: {}
- name: Fh
  id: variable
  parameters:
    comment: |-
      15.625e3 (PAL)
      15.734e3 (NTSC)
    value: Fv*lines_per_frame/2
  states: {}
- name: Fs
  id: variable
  parameters:
    comment: |-
      Fh * (284-1/4) + Fh/625 (pal)
      455 * Fh / 2 (NTSC)
    value: 455 * Fh / 2
  states: {}
- name: Fv
  id: variable
  parameters:
    comment: |-
      50 (PAL)
      60 (NTSC)
    value: '60'
  states: {}
- name: disp_columns
  id: variable
  parameters:
    value: '910'
  states: {}
- name: disp_lines
  id: variable
  parameters:
    value: '263'
  states: {}
- name: dots
  id: variable
  parameters:
    value: disp_lines * disp_columns
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    comment: |-
      625 (PAL)
      526 (NTSC)
      624 (PAL 624)
    value: '526'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: vco_deviation
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    comment: |-
      1.25e-6 VHS
      600e-9 UMATIC
    samp_rate: samp_rate
    tau: '1.25e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*vco_deviation/8.0)
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: Fs
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,Fs*2,1e6)
    type: ccf
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.1'
    grid: 'True'
    gui_hint: '[1,1,1,1]'
    legend: 'False'
    name: '"Input phase"'
    size: '1024'
    style1: '1'
    type: complex
    xmax: '3500'
    xmin: '-3500'
    ymax: '3500'
    ymin: '-3500'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: '[ 1 , 0 , 1, 1]'
    legend: 'False'
    name: '"Input spectra"'
    nconnections: '2'
    type: float
    wintype: firdes.WIN_KAISER
    ymax: '60'
    ymin: '-42'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: '[0,0,1,1]'
    legend: 'False'
    name: '"Input waveform"'
    size: int(2*samp_rate/Fh)
    srate: samp_rate
    type: complex
    ymax: '3500'
    ymin: '-3500'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[0,1,1,2]'
    legend: 'False'
    name: '"Video Out"'
    size: int(2*samp_rate/Fh)
    srate: samp_rate
    tr_level: '0.4'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '9'
    ymin: '-0.7'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/3
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    gui_hint: '[1,2,1,1]'
    legend: 'False'
    name: '"Video Out Spectra"'
    type: float
    wintype: firdes.WIN_KAISER
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:5566
    timeout: '100'
    type: float
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_fm_deemph_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_fm_deemph_0_0, '0', rational_resampler_xxx_0, '0']
- [analog_fm_deemph_0_0, '0', zeromq_rep_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_req_source_0, '0', blocks_complex_to_float_0, '0']
- [zeromq_req_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [zeromq_req_source_0, '0', qtgui_const_sink_x_0, '0']
- [zeromq_req_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
