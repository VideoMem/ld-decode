options:
  parameters:
    generate_options: qt_gui
    id: Velocity_Test
    output_language: python
    title: Head Velocity Test
  states: {}

blocks:
- name: Fc
  id: variable
  parameters:
    comment: 40 * Fh (NTSC)
    value: 40 * Fh
  states: {}
- name: Fh
  id: variable
  parameters:
    comment: |-
      15.625e3 (PAL)
      15.734e3 (NTSC)
    value: Fv*lines_per_frame/2
  states: {}
- name: Fs
  id: variable
  parameters:
    comment: |-
      Fh * (284-1/4) + Fh/625 (pal)
      455 * Fh / 2 (NTSC)
    value: 455 * Fh / 2
  states: {}
- name: Fv
  id: variable
  parameters:
    comment: |-
      50 (PAL)
      60 (NTSC)
    value: '60'
  states: {}
- name: attenuation
  id: variable_qtgui_range
  parameters:
    comment: 19800 umatic
    label: Scale
    orient: Qt.Horizontal
    start: '1'
    step: '100'
    stop: 1e5
    value: 1e5
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: dcbias
  id: variable_qtgui_range
  parameters:
    comment: |-
      5 umatic
      1 VHS
    label: DC Bias
    orient: Qt.Horizontal
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: disp_columns
  id: variable
  parameters:
    value: '910'
  states: {}
- name: disp_lines
  id: variable
  parameters:
    value: '263'
  states: {}
- name: dots
  id: variable
  parameters:
    value: disp_lines * disp_columns
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    comment: |-
      625 (PAL)
      526 (NTSC)
      624 (PAL 624)
    value: '526'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: sdl_rate
  id: variable
  parameters:
    value: dots*Fv
  states: {}
- name: vco_deviation
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: dcbias
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/attenuation
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.5'
    samp_rate: audio_rate
    sensitivity: '4400'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: /home/sebastian/Develop/ld-decode/vhsdecode/chroma_jitterb.wav
    nchan: '2'
    samp_rate: audio_rate
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: round(4*samp_rate/Fv)
    srate: samp_rate
    type: float
    ymax: 1e6
    ymin: '-1e6'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.2'
    grid: 'True'
    label1: Velocity
    label2: '"Velocity VCO"'
    legend: 'False'
    name: '"Velocity"'
    nconnections: '2'
    size: round(4*audio_rate/Fv)
    srate: audio_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ylabel: Δf
    yunit: x100kHz
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    name: '"Acceleration"'
    size: round(4*samp_rate/Fv)
    srate: samp_rate
    tr_level: '-0.2'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ylabel: Acceleration
    yunit: '"100kHz/sec²"'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(audio_rate/samp_rate).limit_denominator(1000).denominator
    interp: Fraction(audio_rate/samp_rate).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_vco_f_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_complex_to_float_0, '0', rational_resampler_xxx_1_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_vco_f_0, '0', blocks_wavfile_sink_0, '1']
- [blocks_vco_f_0, '0', qtgui_time_sink_x_0_0, '1']
- [rational_resampler_xxx_1_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1_0_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_req_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
